# Keil uVision project g030_di2_motor.uvprojx, settings and files
target g030_di2_motor (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: g030_di2_motor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G030xx
  c include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  memory RVCT10: RAM 0x20000800 size 0x1800
  scatter file: g030_di2_motor\g030_di2_motor.sct
  group Application/MDK-ARM
    ../Core/Src/: system_stm32g0xx.c
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: main.c
software components: CMSIS:CORE 4.3.0
